# Keil uVision project spc_firmware.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G8K64 Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x117FF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: spc_firmware-v0.0.1. +hex
  group src
    ./src/: delay.c eeprom.c fan.c main.c power.c rgb.c rtc.c
  group startup
    ./startup/: START251.A51
